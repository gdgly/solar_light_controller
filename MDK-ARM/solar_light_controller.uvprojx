# Keil uVision project solar_light_controller.uvprojx, settings and files
target solar_light_controller (6120000::V6.12::.\ARMCLANG)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: solar_light_controller +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Inc;        ../Drivers/STM32F0xx_HAL_Driver/Inc;        ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;        ../Drivers/CMSIS/Include;        ..\App;        ..\App\hardware;        ..\App\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Hardware
    ../App/hardware/: debug_uart.c
  group Hal
    ../App/hal/: data_interface_hal.c
  group App
    ../App/: soft_timer.c user_main.c adc_algorithm.c kfifo.c
software components: CMSIS:CORE 5.2.0
